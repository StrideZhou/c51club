# Keil uVision project rtx51tiny.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: rtx51tiny +hex
  c flags: Optimize=9
  c define: REMOVEUNUSED
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: rtx51tiny.c Conf_tny.A51 EEPROM.c delay.c
